* EESchema Netlist Version 1.1 (Spice format) creation date: 6/19/2014 11:41:30 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
J1  /VDD N-000048 N-000047 ? /VSS USB-MICRO
U3  N-000050 /VSS N-000051 N-000025 /VSS N-000028 N-000026 N-000055 N-000021 N-000027 /VSS /VSS N-000020 N-000024 N-000027 /VREG MIC2185
R3  N-000050 N-000026 100k
R4  N-000026 /VSS 100k
C5  N-000055 /VSS .1uF
C3  N-000051 /VSS .1uF
R5  N-000025 N-000052 10k
C4  N-000052 /VSS .01uF
C9  N-000021 /VSS 1nF
C10  N-000027 /VSS 1uF
Q1  N-000023 N-000020 N-000022 SI4174DY
R10  N-000022 /VSS .010
R9  N-000021 N-000022 100k
Q2  N-000023 N-000024 /VREG SI4463CDY
D14  N-000023 /VREG B130
C1  N-000050 /VSS 47uF
C2  N-000050 /VSS .1uF
L1  N-000050 N-000023 4.7uH
R13  /VREG N-000028 100k
R14  N-000028 /VSS 31.6k
C13  /VREG /VSS 120uF
C14  /VREG /VSS 120uF
C15  /VREG /VSS 120uF
C16  /VREG /VSS .1uF
U1  N-000019 /VSS /VDISP /VSS /I_SENSE N-000017 N-000017 N-000016 /VSS N-000003 N-000004 N-000005 N-000006 N-000001 N-000008 N-000009 N-000010 N-000011 LM3914
U9  /VSS /VSS /I_SENSE N-000002 N-000033 MAX9938T
D2  /VREG N-000011 LED
D3  /VREG N-000010 LED
D8  /VREG N-000005 LED
D5  /VREG N-000008 LED
D4  /VREG N-000009 LED
D6  /VREG N-000001 LED
D7  /VREG N-000006 LED
D9  /VREG N-000004 LED
D10  /VREG N-000003 LED
D1  /VREG N-000019 LED
J2  /VUSB /D- /D+ /VSS USB
R2  N-000016 N-000017 130k
R1  /VSS N-000016 4.8k
U4  /VDD /VDD N-000063 N-000049 /VSS N-000046 N-000040 N-000045 /VBAT /VBAT MCP73833
C7  /VDD /VSS 4.7uF
C12  /VBAT /VSS 4.7uF
R12  /VSS N-000046 1K
RT1  N-000045 /VSS 10K
U7  /VBAT /VSS BATT
U11  /VDD /VSYS /VDD /VBAT ? /VSYS FDC6392S
R19  /VSS /VDD 100k
D12  /VDD N-000044 LED
D11  /VDD N-000043 LED
D13  /VDD N-000041 LED
R8  N-000044 N-000063 6k
R6  N-000049 N-000043 6k
R11  N-000040 N-000041 6k
F2  N-000034 /VOUT PTC
U2  /VDD ? N-000048 /VSS N-000047 TPD2E001DRL
C8  /VUSB /VSS .1uF
C6  /VDD /VSS .1uF
R20  /VREG N-000034 N-000033 N-000002 .05
U5  /VUSB ? /D- /VSS /D+ TPD2E001DRL
F1  /VSYS N-000050 PTC
U6  /VSS N-000035 /VOUT ? /VOUT /D+ /D- /VUSB TPS2511
R7  /VSS N-000035 34.0k
C11  /VOUT /VSS .1uF
R16  /VREG N-000039 2.55M
R21  N-000029 N-000038 1M
Q3  /VDISP N-000029 /VREG SW
R17  N-000039 N-000031 2.37M
R18  N-000031 N-000037 127k
U8  ? ? ? N-000037 ? N-000039 ? N-000039 MAX6006BESA+
C17  N-000039 /VSS .01uF
U10  N-000038 /I_SENSE N-000031 /VSS /VREG /VSS ? /VREG MCP6042T-I
R22  N-000038 N-000037 10M
R15  N-000037 /VSS 61.9k

.end
